# IAR project usbh_msc.ewp, settings and files
configuration USBFS (ARM, debug)
  General.OGChipSelectEditMenu: GD32F107xC GD GD32F107xC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; USE_USB_FS; GD32F10X_CL
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\..\..\Firmware\CMSIS\GD\GD32F10x\Include; ..\..\..\..\..\Firmware\GD32F10x_standard_peripheral\Include; ..\..\..\..\..\Utilities\LCD_common; ..\..\..\..\..\Utilities\Third_Party\fat_fs\inc; ..\..\..\..\..\Utilities; ..\..\..\..\..\Firmware\GD32F10x_usbfs_library\driver\Include; ..\..\..\..\..\Firmware\GD32F10x_usbfs_library\host\class\msc\Include; ..\..\..\..\..\Firmware\GD32F10x_usbfs_library\host\core\Include; ..\..\..\..\..\Firmware\GD32F10x_usbfs_library\ustd\class\msc; ..\..\..\..\..\Firmware\GD32F10x_usbfs_library\ustd\common
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: USBH_MSC.srec
  ILINK.IlinkOutputFile: usbh_msc.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    ../src/: gd32f10x_it.c gd32f10x_usb_hw.c main.c usbh_usr.c
  group CMSIS
    ../src/: system_gd32f10x.c
  group Doc
    ../: readme.txt
  group FAT_FS
    ../../../../../Utilities/Third_Party/fat_fs/src/: ff.c ffunicode.c
  group GD32F10x_EVAL
    ../../../../../Utilities/: gd32f10x_eval.c gd32f10x_lcd_eval.c
    ../../../../../Utilities/LCD_common/: lcd_font.c lcd_log.c
  group GD32F10x_Peripherals
    ../../../../../Firmware/GD32F10x_standard_peripheral/Source/: gd32f10x_exmc.c gd32f10x_exti.c gd32f10x_gpio.c gd32f10x_misc.c gd32f10x_pmu.c gd32f10x_rcu.c gd32f10x_timer.c gd32f10x_usart.c
  group Startup
    ../../../../../Firmware/CMSIS/GD/GD32F10x/Source/IAR/: startup_gd32f10x_cl.s
  group USB_Class
    ../../../../../Firmware/GD32F10x_usbfs_library/host/class/msc/Source/: usbh_msc_bbb.c usbh_msc_core.c usbh_msc_fatfs.c usbh_msc_scsi.c
  group USB_Driver
    ../../../../../Firmware/GD32F10x_usbfs_library/driver/Source/: drv_usb_core.c drv_usb_host.c drv_usbh_int.c
  group USB_Host
    ../../../../../Firmware/GD32F10x_usbfs_library/host/core/Source/: usbh_core.c usbh_enum.c usbh_pipe.c usbh_transc.c
